# Keil uVision project 51_shell.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 51_shell +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\mysh;.\board
  link misc: NOOVERLAY
  group Startup
    ./: STARTUP.A51
  group User
    ./user/: main.h main.c it.c conf.h
  group Board
    ./board/: dev_uart.h dev_uart.c dev_timer0.h dev_timer0.c
  group Mysh
    ./mysh/: mysh_conf.h mysh.h mysh.c mysh_porting.c
